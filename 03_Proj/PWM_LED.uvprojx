# Keil uVision project PWM_LED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM_LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: ..\01_Src\App\Include;..\01_Src\Board\Include;..\01_Src\CH395\Include;..\01_Src\Com\Include;..\01_Src\Drv\Include;..\02_Lib\CMSIS\STM32F4xx\Include;..\02_Lib\CMSIS\STM32F4xx;..\02_Lib\STM32F4xx_StdPeriph_Lib\Include;..\02_Lib\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../01_Src/App/Source/: main.c stm32f4xx_it.c
  group Com
    ../01_Src/Com/Source/: BufferManage.c LoopList.c
  group Board
    ../01_Src/Board/Source/: Board_LED.c
  group Drv
    ../01_Src/Drv/Source/: Drv_Timer.c Drv_Uart.c Drv_MCU.c
  group Lib
    ../02_Lib/StartUp/: startup_stm32f40xx.s
    ../02_Lib/STM32F4xx_StdPeriph_Lib/Source/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../01_Src/App/Source/: system_stm32f4xx.c
  group CH395
    ../01_Src/CH395/Source/: CH395CMD.C CH395SPI.C
